# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F030C8Tx HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32,HK32F030
  c include: ..\..\..\develop_lib\hk_lib\HK32F030\CMSIS\CM0\CoreSupport;..\..\..\develop_lib\hk_lib\HK32F030\CMSIS\CM0\DeviceSupport\startup;..\..\..\develop_lib\hk_lib\HK32F030\CMSIS\CM0\DeviceSupport;..\..\..\develop_lib\hk_lib\HK32F030\STD_LIB\inc;..\..\..\develop_lib;..\..\..\develop_lib\hk_lib;..\..\..\develop_lib\hk_lib\gpio;..\..\..\develop_lib\hk_lib\systick;..\..\..\develop_lib\middle_api;..\..\..\develop_lib\middle_api\delay;..\..\..\develop_lib\middle_api\mid_gpio;..\..\..\develop_lib\middle_api\mid_systick;..\..\..\develop_lib\hardware;..\..\..\develop_lib\third_lib;..\..\app_hk32f030
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group App
    ../: hk32f0xx_it.c main.c
  group StdPeriph_Driver
    ../../../develop_lib/hk_lib/HK32F030/STD_LIB/src/: hk32f0xx_adc.c hk32f0xx_can.c hk32f0xx_cec.c hk32f0xx_comp.c hk32f0xx_crc.c hk32f0xx_crs.c hk32f0xx_dac.c hk32f0xx_dbgmcu.c hk32f0xx_dma.c hk32f0xx_exti.c hk32f0xx_flash.c hk32f0xx_gpio.c hk32f0xx_i2c.c hk32f0xx_iwdg.c hk32f0xx_misc.c hk32f0xx_pwr.c hk32f0xx_rcc.c hk32f0xx_rtc.c hk32f0xx_spi.c hk32f0xx_syscfg.c hk32f0xx_tim.c hk32f0xx_usart.c hk32f0xx_wwdg.c
  group CMSIS
    ../../../develop_lib/hk_lib/HK32F030/CMSIS/CM0/DeviceSupport/startup/: startup_hk32f030x8.s
    ../: system_hk32f0xx.c
  group hk_lib
    ../../../develop_lib/hk_lib/gpio/: hk_gpio.c
    ../../../develop_lib/hk_lib/systick/: hk_systick.c
  group middle_api
    ../../../develop_lib/middle_api/mid_gpio/: mid_gpio.c
    ../../../develop_lib/middle_api/mid_systick/: mid_systick.c
    ../../../develop_lib/middle_api/delay/: mid_delay.c
