# Keil uVision project HK32F030M_Demo.uvprojx, settings and files
target HK32F030M_Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F030MJ4M6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.12
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F030M_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F030M, HK32F030MJ4M6
  c include: ..\inc;..\..\..\..\..\..\develop_lib\hk_lib\HK32F030M\HK32F030M_Lib\inc;..\..\..\..\..\..\develop_lib\hk_lib\HK32F030M\CMSIS\HK32F030M\Include;..\..\..\..\..\..\develop_lib\hk_lib\HK32F030M\CMSIS\CM0\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Start
    ../../../../../../develop_lib/hk_lib/HK32F030M/CMSIS/HK32F030M/Source/ARM/: KEIL_Startup_hk32f030m.s
  group src
    ../src/: main.c hk32f030m_it.c
    ../../../../../../develop_lib/hk_lib/HK32F030M/CMSIS/HK32F030M/Source/: system_hk32f030m.c
  group HK32F030M_lib
    ../../../../../../develop_lib/hk_lib/HK32F030M/HK32F030M_Lib/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_dbgmcu.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
