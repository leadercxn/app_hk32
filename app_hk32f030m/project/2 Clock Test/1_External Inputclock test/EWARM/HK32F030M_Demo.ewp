# IAR project HK32F030M_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HK32F030MF4 HK HK32F030MF4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HK32F030MF4P6; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\..\..\HK32F030M\CMSIS\CM0\Core; ..\..\..\..\HK32F030M\CMSIS\HK32F030M\Source\IAR; ..\..\..\..\HK32F030M\CMSIS\HK32F030M\Source; ..\..\..\..\HK32F030M\CMSIS\HK32F030M\Include; ..\..\..\..\HK32F030M\HK32F030M_Lib\inc; ..\..\..\..\HK32F030M\HK32F030M_Lib\src; ..\user\src; ..\user\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HK32F030M_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../HK32F030M/CMSIS/HK32F030M/Source/IAR/: IAR_Sartup_hk32f030m.s
    ../../../../HK32F030M/CMSIS/HK32F030M/Source/: system_hk32f030m.c
  group HK32F030M_Lib
    ../../../../HK32F030M/HK32F030M_Lib/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
  group User
    ../user/src/: hk32f030m_it.c main.c uart.c
