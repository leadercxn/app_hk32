# Keil uVision project IAP_App.uvprojx, settings and files
target App (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: App
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F030MF4P6
  c include: ..\source\device\inc;..\source\user;..\source\bsp;..\source\stdlib\inc
  memory RVCT4: ROM 0x8001000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group device
    ../source/device/: startup_hk32f030m.s
  group user
    ../source/user/: hk32f030m_it.c main.c system_hk32f030m.c
  group bsp
    ../source/bsp/: bsp_display.c bsp_hk32f030m_eval.c bsp_iic_eeprom.c bsp_spi_flash.c bsp_system.c bsp_usart.c
  group stdlib
    ../source/stdlib/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
